# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tBitmap.c tLib.h tConfig.h tList.c app.c tCpu.c tTask.c tTime.c tEvent.c tSem.c tMBox.c tMemBlock.c tFlagGroup.c tMutex.c tTimer.c tHooks.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
